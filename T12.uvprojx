# Keil uVision project T12.uvprojx, settings and files
target T12 (5040049::V5.04 update 1 (build 49)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: T12 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Public;.\Hardware\Configurations;.\Hardware\Led;.\Hardware\St7571;.\Hardware\Adc1;.\Hardware\Adc2;.\Hardware\Encoder;.\Hardware\PWM;.\Hardware\Screen;.\Hardware\Data;.\Hardware\Switch;.\Hardware\Eeprom;.\Hardware\Safty
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.cpp stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_md.s
  group Drivers
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dma.c
  group System
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group Hardware
    ./Hardware/Adc1/: Adc1.cpp
    ./Hardware/Led/: Led.cpp
    ./Hardware/St7571/: ST7571.cpp
    ./Hardware/Adc2/: Adc2.cpp
    ./Hardware/Encoder/: Encoder.cpp
    ./Hardware/PWM/: Pwm.cpp
    ./Hardware/Screen/: Screen.cpp
    ./Hardware/Data/: Data.cpp
    ./Hardware/Switch/: Switch.cpp
    ./Hardware/Eeprom/: AT24C02.cpp
    ./Hardware/Safty/: Safty.cpp
  group Public
    ./Public/: SysTick.c Usart.c
